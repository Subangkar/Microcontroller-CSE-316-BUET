;Input
INDEC PROC
;AX HOLDS THE INPUT

PUSH DX

PUSH CX


@BEGIN:  



XOR BX,BX

XOR CX,CX

MOV AH,1
INT 21H

CMP AL,'-'
JE @MINUS
CMP AL,'+'
JE @PLUS
JMP @REPEAT2

@MINUS:
MOV CX,1

@PLUS:
INT 21H

@REPEAT2:
CMP AL,'0'
JNGE @NOT_DIGIT
CMP AL,'9'
JNLE @NOT_DIGIT

AND AX,000FH
PUSH AX

MOV AX,10
MUL BX
POP BX
ADD BX,AX
                     
MOV AH,1
INT 21H
CMP AL,0DH    

JNE @REPEAT2

MOV AX,BX

OR CX,CX
JE @EXIT

NEG AX

@EXIT: 

POP CX

POP DX
RET  

@HALT:
MOV BH,0
JMP @EXIT


@NOT_DIGIT:
CMP AL,'x'
JE @HALT 
MOV AX,BX 
MOV BH,1


OR CX,CX
JE @EXIT

NEG AX

INDEC ENDP